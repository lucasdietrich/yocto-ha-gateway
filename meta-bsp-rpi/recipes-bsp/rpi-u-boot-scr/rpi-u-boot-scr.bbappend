FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

BOOT_MEDIA = "mmc"