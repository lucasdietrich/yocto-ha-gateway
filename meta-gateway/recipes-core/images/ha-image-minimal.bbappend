IMAGE_INSTALL:append = "\
    dnsmasq \
    ntpd-start \
    tzdata \
    openssl \
    mbedtls \
"