require python3-cancontroller.inc

SRCREV = "ab9f42ace164222f7e61e9de9065bb8b2ee4779a"