require python3-cancontroller.inc

SRCREV = "3efb9bff6f01037019d08722bc1151eb4b89826b"
