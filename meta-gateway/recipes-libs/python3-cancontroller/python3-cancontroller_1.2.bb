require python3-cancontroller.inc

SRCREV = "95c74e38d50491e771c97e65f7afb12da01a17fc"
