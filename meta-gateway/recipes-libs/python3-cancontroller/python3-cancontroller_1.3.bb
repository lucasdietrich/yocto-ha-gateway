require python3-cancontroller.inc

SRCREV = "56294f881ccc91b6b9edc43f438978fe901eeed8"
